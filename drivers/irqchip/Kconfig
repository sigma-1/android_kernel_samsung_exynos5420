## drivers/irqchip/Kconfig
```kconfig
config IRQCHIP
	def_bool y
	depends on OF_IRQ

config ARM_GIC
	select IRQ_DOMAIN
	select MULTI_IRQ_HANDLER
	bool

config GIC_NON_BANKED
	bool
```
